Commit message: pratica 03

File: src/robot_description/model_description/my_robot/my_robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 3 links, 2 joints
Links:
- link chassis: geometry collision box size=0.4 0.2 0.1; collision sphere radius=0.05
